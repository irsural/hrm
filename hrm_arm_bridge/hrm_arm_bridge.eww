<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\hrm_arm_bridge.ewp</path>
  </project>
  <batchBuild/>
</workspace>


